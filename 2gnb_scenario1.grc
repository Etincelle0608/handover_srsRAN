options:
  parameters:
    generate_options: qt_gui
    id: multi_ue_scenario
    output_language: python
    title: srsRAN_multi_UE
  states: {}

blocks:
- name: c
  id: variable
  parameters:
    value: '300000000'
  states: {}
- name: frequence
  id: variable
  parameters:
    value: '3685000000'
  states: {}
- name: gain_gNB1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-02'
    stop: '1'
    value: '1'
  states: {}
- name: gain_gNB2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-02'
    stop: '1'
    value: '0'
  states: {}
- name: gain_ue1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-04'
    stop: '1'
    value: '1'
  states: {}
- name: gain_ue2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-04'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '500'
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_ue1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_gNB2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_gNB1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_ue2
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: 'import math '
  states: {}
- name: zeromq_rep_sink_0_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:4100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:3001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:4101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_2
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_2_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:3000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}

connections:
- [blocks_add_xx_0_1, '0', blocks_throttle_0_0_2, '0']
- [blocks_multiply_const_vxx_0, '0', zeromq_rep_sink_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_1, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0_1, '0']
- [blocks_multiply_const_vxx_0_2, '0', zeromq_rep_sink_0_1_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_throttle_0_0_2, '0', zeromq_rep_sink_0_0_1, '0']
- [zeromq_req_source_1, '0', blocks_throttle_0, '0']
- [zeromq_req_source_1_2, '0', blocks_multiply_const_vxx_0_1, '0']
- [zeromq_req_source_1_2_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    generate_options: qt_gui
    id: multi_ue_scenario
    output_language: python
    title: srsRAN_multi_UE
  states: {}

blocks:
- name: X1
  id: variable
  parameters:
    value: '-300'
  states: {}
- name: X2
  id: variable
  parameters:
    value: '100'
  states: {}
- name: X3
  id: variable
  parameters:
    value: '-900'
  states: {}
- name: X4
  id: variable
  parameters:
    value: '700'
  states: {}
- name: c
  id: variable
  parameters:
    value: '300000000'
  states: {}
- name: frequence
  id: variable
  parameters:
    value: '3685000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: slow_down_ratio
  id: variable_qtgui_range
  parameters:
    label: Time Slow Down Ratio
    start: '1'
    step: '1'
    stop: '32'
    value: '1'
  states: {}
- name: speed1
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option0: '10'
    option1: '30'
    option2: '60'
    option3: '70'
    type: int
    value: '30'
  states: {}
- name: speed2
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option0: '10'
    option1: '30'
    option2: '60'
    option3: '70'
    type: int
    value: '30'
  states: {}
- name: speed3
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option0: '10'
    option1: '30'
    option2: '60'
    option3: '70'
    type: int
    value: '30'
  states: {}
- name: speed4
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option0: '10'
    option1: '30'
    option2: '60'
    option3: '70'
    type: int
    value: '30'
  states: {}
- name: t
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '3000'
    value: '0'
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '500'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-math.log10(abs(X1-speed1*t/3.6))-math.log10(frequence)-math.log10(4*math.pi/c))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-math.log10(abs(X2-speed2*t/3.6))-math.log10(frequence)-math.log10(4*math.pi/c))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-math.log10(abs(X3+speed3*t/3.6))-math.log10(frequence)-math.log10(4*math.pi/c))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-math.log10(abs(X4+speed4*t/3.6))-math.log10(frequence)-math.log10(4*math.pi/c))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-math.log10(abs(X1-speed1*t/3.6))-math.log10(frequence)-math.log10(4*math.pi/c))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-math.log10(abs(X2-speed2*t/3.6))-math.log10(frequence)-math.log10(4*math.pi/c))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-math.log10(abs(X3+speed3*t/3.6))-math.log10(frequence)-math.log10(4*math.pi/c))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-math.log10(abs(X4+speed4*t/3.6))-math.log10(frequence)-math.log10(4*math.pi/c))
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_dynamic_channel_model_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (speed1/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: '0'
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_0_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (speed2/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: '0'
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_0_0_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (speed4/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: '0'
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_0_0_1
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (speed3/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: '0'
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_1
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (speed1/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: '0'
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_2
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (speed2/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: '0'
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_2_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (speed3/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: '0'
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_2_1
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (speed4/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: '0'
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: 'import math '
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2200
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2400
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2300
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2201
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2301
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_0_1
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2401
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', zeromq_rep_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_throttle_0_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_throttle_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_throttle_0_1, '0']
- [blocks_multiply_const_vxx_0_2_0, '0', blocks_throttle_0_1_1, '0']
- [blocks_multiply_const_vxx_0_2_1, '0', blocks_throttle_0_1_0, '0']
- [blocks_throttle_0, '0', channels_dynamic_channel_model_0, '0']
- [blocks_throttle_0_0, '0', channels_dynamic_channel_model_1, '0']
- [blocks_throttle_0_0_0, '0', channels_dynamic_channel_model_2, '0']
- [blocks_throttle_0_0_0_0, '0', channels_dynamic_channel_model_2_1, '0']
- [blocks_throttle_0_0_0_1, '0', channels_dynamic_channel_model_2_0, '0']
- [blocks_throttle_0_1, '0', channels_dynamic_channel_model_0_0, '0']
- [blocks_throttle_0_1_0, '0', channels_dynamic_channel_model_0_0_0, '0']
- [blocks_throttle_0_1_1, '0', channels_dynamic_channel_model_0_0_1, '0']
- [channels_dynamic_channel_model_0, '0', blocks_add_xx_0, '0']
- [channels_dynamic_channel_model_0_0, '0', blocks_add_xx_0, '1']
- [channels_dynamic_channel_model_0_0_0, '0', blocks_add_xx_0, '3']
- [channels_dynamic_channel_model_0_0_1, '0', blocks_add_xx_0, '2']
- [channels_dynamic_channel_model_1, '0', zeromq_rep_sink_0, '0']
- [channels_dynamic_channel_model_2, '0', zeromq_rep_sink_0_0, '0']
- [channels_dynamic_channel_model_2_0, '0', zeromq_rep_sink_0_0_1, '0']
- [channels_dynamic_channel_model_2_1, '0', zeromq_rep_sink_0_0_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [zeromq_req_source_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [zeromq_req_source_1_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [zeromq_req_source_1_0_0, '0', blocks_multiply_const_vxx_0_2_0, '0']
- [zeromq_req_source_1_0_1, '0', blocks_multiply_const_vxx_0_2_1, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3

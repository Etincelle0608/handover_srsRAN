options:
  parameters:
    author: Expert srsRAN
    category: Custom
    generate_options: qt_gui
    id: handover_test
    output_language: python
    title: Handover Simulation (gNB1 <-> gNB2)
  states: {}

blocks:
- name: gain_gn1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: gain_gn2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: ho_gn1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: ho_gn2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '500'
  states: {}
- name: add_signals
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: gnb1_rx_sink
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:2001
    timeout: zmq_timeout
    type: complex
  states: {}
- name: gnb1_tx_source
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:2000
    timeout: zmq_timeout
    type: complex
  states: {}
- name: gnb2_rx_sink
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:3001
    timeout: zmq_timeout
    type: complex
  states: {}
- name: gnb2_tx_source
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:3000
    timeout: zmq_timeout
    type: complex
  states: {}
- name: multiply_gnb1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_gn1
    type: complex
  states: {}
- name: multiply_gnb1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_gn1
    type: complex
  states: {}
- name: multiply_gnb2
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_gn2
    type: complex
  states: {}
- name: multiply_gnb2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_gn2
    type: complex
  states: {}
- name: throttle_dl
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: throttle_ul
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: ue_rx_sink
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:4100
    timeout: zmq_timeout
    type: complex
  states: {}
- name: ue_tx_source
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:4101
    timeout: zmq_timeout
    type: complex
  states: {}

connections:
- [add_signals, '0', throttle_dl, '0']
- [gnb1_tx_source, '0', multiply_gnb1, '0']
- [gnb2_tx_source, '0', multiply_gnb2, '0']
- [multiply_gnb1, '0', add_signals, '0']
- [multiply_gnb1_0, '0', gnb2_rx_sink, '0']
- [multiply_gnb2, '0', add_signals, '1']
- [multiply_gnb2_0, '0', gnb1_rx_sink, '0']
- [throttle_dl, '0', ue_rx_sink, '0']
- [throttle_ul, '0', multiply_gnb1_0, '0']
- [throttle_ul, '0', multiply_gnb2_0, '0']
- [ue_tx_source, '0', throttle_ul, '0']

metadata:
  file_format: 1
